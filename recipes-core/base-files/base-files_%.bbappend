FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# No extra code is strictly needed if the file is named 'issue', 
# as the base recipe will automatically pick it up from FILESEXTRAPATHS.
