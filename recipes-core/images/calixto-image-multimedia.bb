require recipes-fsl/images/imx-image-multimedia.bb
