require dynamic-layers/qt6-layer/recipes-fsl/images/imx-image-full.bb
