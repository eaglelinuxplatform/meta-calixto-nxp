require recipes-sato/images/core-image-sato.bb
