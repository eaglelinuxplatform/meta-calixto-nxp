require recipes-fsl/images/imx-image-core.bb

