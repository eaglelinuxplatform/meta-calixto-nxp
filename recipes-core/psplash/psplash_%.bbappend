FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://calixto_splash.png"


SPLASH_IMAGES = "file://custom-logo.png;outsuffix=default"

